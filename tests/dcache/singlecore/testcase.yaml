## tests/dcache/singlecore/testcase.yaml
```yaml
tests:
  dcache.singlecore:
    platform_allow:
      nrf54h20dk_nrf54h20_cpuapp
    integration_platforms:
      - nrf54h20dk_nrf54h20_cpuapp
```
